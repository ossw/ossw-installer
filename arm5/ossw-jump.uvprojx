# Keil uVision project ossw-jump.uvprojx, settings and files
target nrf51822_xxaa (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.1.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: flashwrite_example_arm +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: NRF51
  c misc: --c99
  c include: C:\nrf51_sdk_v5_2_0\nrf51822\Include;C:\nrf51_sdk_v5_2_0\nrf51822\Include\ble
  library: MicroLIB
  memory RVCT4: ROM 0x14000 size 0x1000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group app
    C:/nrf51_sdk_v5_2_0/nrf51822/Source/: keil_arm_uv4.lnt
    ../: main_jump.c
  group core
    C:/nrf51_sdk_v5_2_0/nrf51822/Source/templates/arm/: arm_startup_nrf51.s
    C:/nrf51_sdk_v5_2_0/nrf51822/Source/templates/: system_nrf51.c
