# Keil uVision project ossw-installer.uvprojx, settings and files
target nrf51822_xxaa (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.1.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ossw-installer +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NRF51
  c misc: --c99
  c include: C:\nrf51_sdk_v5_2_0\nrf51822\Include;C:\nrf51_sdk_v5_2_0\nrf51822\Include\ble
  library: MicroLIB
  memory RVCT4: ROM 0x20003000 size 0x1000
  memory RVCT9: RAM 0x20001000 size 0x2000
  group app
    ../: main_installer.c ext_flash.c ext_flash.h spi.c spi.h boards.h mlcd.c mlcd.h
  group core
    C:/nrf51_sdk_v5_2_0/nrf51822/Source/templates/arm/: arm_startup_nrf51.s
    C:/nrf51_sdk_v5_2_0/nrf51822/Source/templates/: system_nrf51.c
